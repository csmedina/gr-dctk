<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>generic_rx_path</value></param>
<param><key>title</key><value>Generic receiver path</value></param>
<param><key>author</key><value>Cesar Medina</value></param>
<param><key>description</key><value>This block represents a generic receiver path, which implements the phase, frame, carrier and symbol sinchronism. Also it cuts the frame into header and payload frames.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_header_len</value></param>
<param><key>value</key><value>sync_seq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tag_len_name</value></param>
<param><key>value</key><value>"tag_len_name"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Threshold for frame detection</value></param>
<param><key>value</key><value>0.85</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_seq</value></param>
<param><key>label</key><value>Reference symbols</value></param>
<param><key>value</key><value>10</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>payload_len</value></param>
<param><key>label</key><value>Payload Len</value></param>
<param><key>value</key><value>85</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>incoming_symbols</value></param>
<param><key>label</key><value>Incoming symbols</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>sync_header_len</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>out_hdr</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>header_tag</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>header_tag</value></param>
</block>
<block>
<key>dctk_header_tag_generator</key>
<param><key>id</key><value>dctk_header_tag_generator_0</value></param>
<param><key>header_len</key><value>sync_header_len</value></param>
<param><key>payload_len</key><value>payload_len</value></param>
<param><key>length_tag_name</key><value></value></param>
</block>
<block>
<key>dctk_frame_sync</key>
<param><key>id</key><value>dctk_frame_sync_0</value></param>
<param><key>sync_sequence</key><value>[complex(1,0),complex(-1,0)]</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>out_hdr</value></param>
</block>
<block>
<key>digital_header_payload_demux</key>
<param><key>id</key><value>digital_header_payload_demux_0</value></param>
<param><key>header_len</key><value>sync_header_len</value></param>
<param><key>items_per_symbol</key><value>1</value></param>
<param><key>length_tag_key</key><value>tag_len_name</value></param>
<param><key>output_symbols</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>Header data</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>label</key><value>Detection trigger</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>label</key><value>Payload Data</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>incoming_symbols</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>incoming_symbols</source_block_id><sink_block_id>dctk_frame_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dctk_frame_sync_0</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dctk_frame_sync_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_header_payload_demux_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>dctk_header_tag_generator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dctk_header_tag_generator_0</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>header_data</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>0</source_key><sink_key>header_data</sink_key></connection>
<connection><source_block_id>dctk_frame_sync_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_header_payload_demux_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
