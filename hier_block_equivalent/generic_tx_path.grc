<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_packet_len</value></param>
<param><key>value</key><value>96</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_packet_len</value></param>
<param><key>value</key><value>96</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink</value></param>
<param><key>label</key><value>Tagged Stread</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>dctk_stream_to_tagged_stream_cc</key>
<param><key>id</key><value>dctk_stream_to_tagged_stream_cc_1</value></param>
<param><key>len_stream</key><value>payload_packet_len</value></param>
<param><key>tags</key><value>length_tag_name</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ninputs</key><value>2</value></param>
<param><key>lengthtagname</key><value>length_tag_name</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>untagged_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>untagged_stream_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>dctk_stream_to_tagged_stream_cc</key>
<param><key>id</key><value>dctk_stream_to_tagged_stream_cc_0</value></param>
<param><key>len_stream</key><value>sync_packet_len</value></param>
<param><key>tags</key><value>length_tag_name</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>length_tag_name</value></param>
<param><key>label</key><value>Length tag name</value></param>
<param><key>value</key><value>"packet_len"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<connection><source_block_id>dctk_stream_to_tagged_stream_cc_1</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>pad_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>dctk_stream_to_tagged_stream_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>dctk_stream_to_tagged_stream_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dctk_stream_to_tagged_stream_cc_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
