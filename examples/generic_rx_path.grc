<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>generic_rx_path</value></param>
<param><key>title</key><value>Generic receiver path</value></param>
<param><key>author</key><value>Cesar Medina (csmedina@gmail.com)</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>DCTK</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tag_len_name</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>Frequency compensated signal</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>incoming data</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>sync_header_len</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>analog_frequency_modulator_fc_0</value></param>
<param><key>sensitivity</key><value>frequency_mod_sensitivity</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>Frequency deviation</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_header_len</value></param>
<param><key>label</key><value>Synchronization header length</value></param>
<param><key>value</key><value>96</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>items_per_header_symbol</value></param>
<param><key>label</key><value>Items per header symbol</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency_mod_sensitivity</value></param>
<param><key>label</key><value>Frequency compesation sensitivity</value></param>
<param><key>value</key><value>-2</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>payload_len</value></param>
<param><key>label</key><value>Payload length</value></param>
<param><key>value</key><value>96</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>dctk_header_tag_generator</key>
<param><key>id</key><value>dctk_header_tag_generator_0</value></param>
<param><key>header_len</key><value>sync_header_len</value></param>
<param><key>payload_len</key><value>payload_len</value></param>
<param><key>length_tag_name</key><value>tag_len_name</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0</value></param>
<param><key>label</key><value>Trigger</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>Frequency compensated signal</value></param>
</block>
<block>
<key>digital_header_payload_demux</key>
<param><key>id</key><value>digital_header_payload_demux_0</value></param>
<param><key>header_len</key><value>sync_header_len</value></param>
<param><key>items_per_symbol</key><value>items_per_header_symbol</value></param>
<param><key>length_tag_key</key><value>tag_len_name</value></param>
<param><key>output_symbols</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>Header Symbols</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>label</key><value>Payload Symbols</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_frequency_modulator_fc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>analog_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dctk_header_tag_generator_0</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>header_data</source_key><sink_key>header_data</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>dctk_header_tag_generator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_header_payload_demux_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_header_payload_demux_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_header_payload_demux_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
